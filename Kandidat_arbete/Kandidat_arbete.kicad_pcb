# Repository jawedhakimi/Kandidatarbete-v2

## KiCad design Kandidat_arbete/Kandidat_arbete.kicad_pcb

Parts:
C100, C101: 10u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; PARTREV C96446; JLC C96446
C104: 10nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; PARTREV C57112
C108: 1uF; C_0805_2012Metric; PARTREV C28323
Cp102: 0u47F/50V; C_0805_2012Metric; PARTREV C13967
Cp103: 2u2F/50V; C_1210_3225Metric; PARTREV C49217
Cp105: 3u3F; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; PARTREV C338093
Cp106: 0u1; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; PARTREV C14663
Cp107: 22u/25; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; PARTREV C45783
D100: D_Zener_Small; D_SMA; PARTREV C8062
D101, D103: RED; LED_0805_2012Metric; PARTREV C84256
D_Sch100: D_Schottky_Small; do-214AC-2; PARTREV C8678; Mouser 637-SK35SMA
F100: 500mA; Fuse_1206_3216Metric; PARTREV C8678
J100: Screw_Terminal_01x02; TerminalBlock_bornier-2_P5.08mm
JP100: Jumper_3_Open; PinHeader_1x03_P2.54mm_Vertical
L100: 220u; L_Bourns_SRR1208_12.7x12.7mm; PARTREV C2929503; Mouser 652-SRR1208-221KL
Q100: BSP 171; bsp171; PARTREV C15127; Mouser 726-BSP171PH6327
R100: 10k; R_0603_1608Metric; PARTREV C25804
R102: 1k; R_0603_1608Metric; PARTREV C22764
R103: 127k; R_0603_1608Metric; PARTREV C25804
R104: 14k; R_0603_1608Metric; PARTREV C25804
R105: 47k; R_0603_1608Metric; PARTREV C25804
R106: 4M7; R_0603_1608Metric; PARTREV C25804
R107: 1k; R_0603_1608Metric; PARTREV C25804
R108: 499k; R_0603_1608Metric; PARTREV C25804
R109: 10k; R_0603_1608Metric; PARTREV C22764
RV1: R_Potentiometer_Small; TRIM_TC33X-2-103E
U1: LM5017MR; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.95x4.9mm_Mask2.71x3.4mm_Th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; PARTREV C34355; Mouser 926-LM5017MRX/NOPB
U101: LVR 3.3V; SOT-223-3_TabPin2; PARTREV C277892; Mouser 584-ADP3338AKCZ3.3R

Connections:
+3.3V: C101.1, D101.2 (A), U101.2 (VO); also elsewhere on the board
+5V: JP100.1 (A); also elsewhere on the board
+BATT: F100.1, J100.1
/Power circuitery/BST: C104.1, U1.7 (BST)
/Power circuitery/FB: Cp106.1, R107.2, RV1.2, RV1.3, U1.5 (FB)
/Power circuitery/LinReg_in: C100.1, JP100.2 (C), U101.3 (VI)
/Power circuitery/SW: C104.2, L100.1, R105.1, R106.1, U1.8 (SW)
/Power circuitery/ULVO: R103.1, R104.2, U1.3 (ULVO)
GND: C100.2, C101.2, C108.1, Cp102.2, Cp103.2, Cp107.2, J100.2, R100.2, R102.1, R104.1, R107.1, R109.1, U1.1 (RTN), U1.9 (RTNPAD), U101.1 (GND); also elsewhere on the board
unnamed: Cp105.1, Cp106.2, R105.2, R106.2
unnamed: D100.2 (A), Q100.1 (G), R100.1
unnamed: D100.1 (K), F100.2, Q100.3 (D)
unnamed: D101.1 (K), R102.2
unnamed: D103.1 (K), R109.2
unnamed: R108.2, U1.4 (RON)
SW_REG_OUT: Cp105.2, Cp107.1, D103.2 (A), D_Sch100.A, JP100.3 (B), L100.2, RV1.1
S_reg_in: Cp102.1, Cp103.1, Q100.2 (S), R103.2, R108.1, U1.2 (VIN)
VCC_LM5017: C108.2, D_Sch100.C (K), U1.6 (VCC)

Notes on the sheet:
Buck converter, 50V to 12V
5V comes from VBUS
Power Circuit
The Schottky diode is of type: B5819W SL https://jlcpcb.com/partdetail/9093-B5819WSL/C8598
The switching reg. XL1509-ADJE1 has input voltage og max 40V https://jlcpcb.com/partdetail/Xlsemi-XL1509_50E1/C61063
Linear Voltage reg. is of type: NCP1117ST33T3G https://uk.farnell.com/on-semiconductor/ncp1117st33t3g/ic-linear-voltage-regulator/dp/1652366?st=ldo%20regulator
Power indicating LED
Short circuit and Reverse input protection
P-channel mosfet 2N7002 https://jlcpcb.com/partdetail/9040-2N7002/C8545
The 47uH inductor is of type; CKST0605-47uH/M https://jlcpcb.com/partdetail/Cenker-CKST0605_47uHM/C3002654

Parts:
C200: 4u7; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; PARTREV C29823; JLC C29823
C201, C202, C203, C204, C205, C212: 100n; C_0603_1608Metric; PARTREV C14663
C206: 1u; C_0603_1608Metric; PARTREV C15849
C207: 10n; C_0603_1608Metric; PARTREV C57112
C208, C209: 2u2; C_0603_1608Metric; PARTREV C23630
C210, C211: 12p; C_0603_1608Metric; PARTREV C38523
D200: Yellow; LED_0603_1608Metric; PARTREV C84256
D201: B; LED_0603_1608Metric; PARTREV C84256
D202: G; LED_0603_1608Metric; PARTREV C84256
D203: R; LED_0603_1608Metric; PARTREV C84256
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_Via
J200: Conn_02x05_Odd_Even; PinSocket_2x05_P2.54mm_Vertical
J201, J203, J204, J205: Conn_01x04; PinSocket_1x04_P2.54mm_Vertical
J207, J208, J209: Conn_01x05; PinSocket_1x05_P2.54mm_Vertical
L200: 10u; L_1206_3216Metric; PARTREV C1051; Mouser 710-742792151
R200: 10k; R_0603_1608Metric; PARTREV C25804
R201: 0; R_0603_1608Metric; PARTREV C22764
R202, R203: 2k2; R_0603_1608Metric; PARTREV C23162
R204, R205, R206, R207: 1k; R_0603_1608Metric; PARTREV C25804
R208, R209: 5k1; R_0603_1608Metric; PARTREV C25804
R405, R406, R407: 22; R_0603_1608Metric; PARTREV C227717
SW200: BOOT0; SW_SPDT_PCM12
U200: STM32F405RGT6; LQFP-64_10x10mm_P0.5mm; PARTREV C15742; Mouser 511-STM32F405RGT6
U201: USBLC6-2SC6; SOT-23-6; PARTREV C5261088; Mouser 511-USBLC6-2SC6
USB_C1: USB_C_receptacle; JAE_DX07S016JA1R1500; PARTREV C5261088; Mouser 656-DX07S016JA1R1500
Y200: 16Mhz; Crystal_SMD_3225-4Pin_3.2x2.5mm; PARTREV C13738; Mouser 815-ASEAIG-16MHZ-CST

Connections:
+3.3V: C200.1, C201.1, C202.1, C203.1, C204.1, C205.1, J200.1, J201.1, J203.1, J204.1, J205.1, J207.1, J208.1, L200.1, R202.2, R203.2, SW200.3 (C), U200.1 (VBAT), U200.19 (VDD), U200.32 (VDD), U200.48 (VDD), U200.64 (VDD); also elsewhere on the board
+3.3VA: C206.1, C207.1, L200.2, U200.13 (VDDA)
+5V: U201.5 (VBUS), USB_C1.2 (VBUS), USB_C1.11 (VBUS); also elsewhere on the board
/STM32 and Connectivity/BOOT0: R200.2, U200.60 (BOOT0)
CAN1_RX: J201.2, U200.61 (PB8)
CAN1_TX: J201.3, U200.62 (PB9)
GND: C200.2, C201.2, C202.2, C203.2, C204.2, C205.2, C206.2, C207.2, C208.2, C209.2, C210.2, C211.2, C212.2, H1.1, H2.1, H3.1, H4.1, J200.3, J200.5, J200.9, J201.4, J203.4, J204.4, J205.4, J207.5, J208.5, R204.1, R205.1, R206.1, R207.1, R208.1, R209.1, SW200.1 (A), U200.12 (VSSA), U200.18 (VSS), U200.63 (VSS), U201.2 (GND), USB_C1.1 (GND), USB_C1.12 (GND), USB_C1.S1 (SHIELD), USB_C1.S2 (SHIELD), USB_C1.S3 (SHIELD), USB_C1.S4 (SHIELD), USB_C1.S5 (SHIELD), USB_C1.S6 (SHIELD), Y200.2, Y200.4; also elsewhere on the board
I2C2_SCL: J203.2, R202.1, U200.29 (PB10); also elsewhere on the board
I2C2_SDA: J203.3, R203.1, U200.30 (PB11); also elsewhere on the board
INT1: J208.2; also elsewhere on the board
INT2: J208.3; also elsewhere on the board
LED1: D200.2 (A), U200.53 (PC12)
LED2: D201.2 (A), U200.2 (PC13)
LED3: D202.2 (A), U200.3 (PC14)
LED4: D203.2 (A), U200.4 (PC15)
NRST: R407.2, U200.7 (NRST)
unnamed: C208.1, U200.31 (VCAP_1)
unnamed: C209.1, U200.47 (VCAP_2)
unnamed: C211.1, R201.1, Y200.3
unnamed: D200.1 (K), R204.2
unnamed: D201.1 (K), R205.2
unnamed: D202.1 (K), R206.2
unnamed: D203.1 (K), R207.2
unnamed: J200.2, R405.1
unnamed: J200.4, R406.1
unnamed: C212.1, J200.10, R407.1
unnamed: R200.1, SW200.2 (B)
unnamed: C210.1, U200.5 (PH0), Y200.1
unnamed: R201.2, U200.6 (PH1)
unnamed: R209.2, USB_C1.3 (CC1)
unnamed: R208.2, USB_C1.9 (CC2)
PC0: J209.1, U200.8 (PC0)
PC1: J209.2, U200.9 (PC1)
PC2: J209.3, U200.10 (PC2)
PC3: J209.4, U200.11 (PC3)
PC4: J209.5
SA0: J208.4; also elsewhere on the board
SPI1_MISO: J207.3, U200.22 (PA6)
SPI1_MOSI: J207.4, U200.23 (PA7)
SPI1_SCK: J207.2, U200.21 (PA5)
SWCLK: R406.2, U200.49 (PA14)
SWDIO: R405.2, U200.46 (PA13)
SWO: J200.6, U200.55 (PB3)
UART2_RX: J204.3, U200.17 (PA3)
UART2_TX: J204.2, U200.16 (PA2)
UART3_RX: J205.3, U200.52 (PC11)
UART3_TX: J205.2, U200.51 (PC10)
USB_CONN_D+: U201.3 (I/O2), USB_C1.6 (D+), USB_C1.7 (D+)
USB_CONN_D-: U201.1 (I/O1), USB_C1.5 (D-), USB_C1.8 (D-)
USB_D+: U200.45 (PA12), U201.4 (I/O2)
USB_D-: U200.44 (PA11), U201.6 (I/O1)

Notes on the sheet:
Interface and Connectivity
i2c pullups
C_load = 2*(C_cryst_load-C_stray_PCB), per side crystal pin. C_PCB ~= 6p
ESD protection
STM32 microcontroller
C_dec is 100nF per VDD and VBAT + 4.7uF

Parts:
C300: 0u22; C_0603_1608Metric; PARTREV C21122
C301: 4u7; C_0805_2012Metric; PARTREV C29823
C302: 4u7; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; PARTREV C29823; JLC C29823
C303, C304, C307: 0u1; C_1206_3216Metric; PARTREV C14663
C305: 0u1; C_0805_2012Metric; PARTREV C14663
C306: 10n; C_0603_1608Metric; PARTREV C57112
C308: 2n2; C_0603_1608Metric; PARTREV C1604
HMC5883: HMC5883L; PLCC16-0.5-3X3MM; MPN HMC5883L
J300: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
MMA8451: MMA8451QR1; QFN50P300X300X100-16N; MPN MMA8451QR1
MPU6050: MPU-6050; InvenSense_QFN-24_4x4mm_P0.5mm; PARTREV C24112; Mouser 410-MPU-6050
R300: 10k; R_0603_1608Metric; PARTREV C25804
R301, R302: 100; R_0603_1608Metric; PARTREV C22775
R303: 22; R_0603_1608Metric; PARTREV C25804

Connections:
+3.3V: C302.1, C303.1, C305.1, C306.1, HMC5883.2 (2(VDD)), HMC5883.13 (13(VDDIO)), MMA8451.1 (VDDIO), MMA8451.14 (VDD), MPU6050.8 (VDDIO), MPU6050.13 (VDD), R300.1, R301.1, R303.1; also elsewhere on the board
/Sensors/AUX_SCL: J300.3, MPU6050.7 (AUX_SCL)
/Sensors/AUX_SDA: J300.2, MPU6050.6 (AUX_SDA)
/Sensors/BYP: C304.1, MMA8451.2 (BYP)
/Sensors/INT: J300.1, MPU6050.12 (INT)
GND: C301.2, C302.2, C303.2, C304.2, C305.2, C306.2, C307.2, C308.2, HMC5883.9 (9(GND)), HMC5883.11 (11(GND)), MMA8451.5 (GND_3), MMA8451.10 (GND_2), MMA8451.12 (GND), MPU6050.1 (CLKIN), MPU6050.11 (FSYNC), MPU6050.18 (GND), R302.1; also elsewhere on the board
I2C2_SCL: HMC5883.1 (1(SCL)), MMA8451.4 (SCL), MPU6050.23 (SCL); also elsewhere on the board
I2C2_SDA: HMC5883.16 (16(SDA)), MMA8451.6 (SDA), MPU6050.24 (SDA); also elsewhere on the board
INT1: MMA8451.11 (INT1); also elsewhere on the board
INT2: MMA8451.9 (INT2); also elsewhere on the board
MPU6050_AD0: MPU6050.9 (AD0), R301.2, R302.2
unnamed: HMC5883.4 (4(S1)), R303.2
unnamed: C300.2, HMC5883.8 (8(SETP))
unnamed: C301.1, HMC5883.10 (10(C1))
unnamed: C300.1, HMC5883.12 (12(SETC))
unnamed: C308.1, MPU6050.20 (CPOUT)
unnamed: C307.1, MPU6050.10 (REGOUT)
SA0: MMA8451.7 (SA0), R300.2; also elsewhere on the board

Notes on the sheet:
AD0 = 0, Adr: 1101000 AD0 = 1, Adr: 1101001
MPU6050
MMA8451QR1
HMC5883L
Regulator Filter Capacitor (Pin 10) 0.1µF ±10%, 2V VDD Bypass Capacitor (Pin 13) 0.1µF ±10%, 4V Charge Pump Capacitor (Pin 20) 2.2nF ±10%, 50V VLOGIC Bypass Capacitor (Pin 8) 10nF ±10%, 4V

Board: 4 copper layers, 100.0 x 75.0 mm, 95 parts (0 on the bottom side), 76 nets.

File Kandidat_arbete/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
C100,0603,1,10u,C96446
C101,0603,1,10u,C96446
C104,0603,1,10nF,
C108,0805,1,1uF,
C200,1206,1,4u7,C29823
C201,0603,1,100n,
C202,0603,1,100n,
C203,0603,1,100n,
C204,0603,1,100n,
C205,0603,1,100n,
C206,0603,1,1u,
C207,0603,1,10n,
C208,0603,1,2u2,
C209,0603,1,2u2,
C210,0603,1,12p,
C211,0603,1,12p,
C212,0603,1,100n,
C300,0603,1,0u22,
C301,0805,1,4u7,
C302,1206,1,4u7,C29823
C303,1206,1,0u1,
C304,1206,1,0u1,
C305,0805,1,0u1,
C306,0603,1,10n,
C307,1206,1,0u1,
C308,0603,1,2n2,
Cp102,0805,1,0u47F/50V,
Cp103,1210,1,2u2F/50V,
Cp105,1206,1,3u3F,
Cp106,0603,1,0u1,
Cp107,0805,1,22u/25,
D100,D_SMA,1,D_Zener_Small,
D101,0805,1,RED,
D103,0805,1,RED,
D200,0603,1,Yellow,
D201,0603,1,B,
D202,0603,1,G,
D203,0603,1,R,
D_Sch100,do-214AC-2,1,D_Schottky_Small,
F100,1206,1,500mA,
"H1, H2, H3, H4",MountingHole_3.2mm_M3_Pad_Via,4,MountingHole_Pad,
HMC5883,PLCC16-0.5-3X3MM,1,HMC5883L,
J100,TerminalBlock_bornier-2_P5.08mm,1,Screw_Terminal_01x02,
J200,PinSocket_2x05_P2.54mm_Vertical,1,Conn_02x05_Odd_Even,
"J201, J203, J204, J205",PinSocket_1x04_P2.54mm_Vertical,4,Conn_01x04,
"J207, J208, J209",PinSocket_1x05_P2.54mm_Vertical,3,Conn_01x05,
J300,PinHeader_1x03_P2.54mm_Vertical,1,Conn_01x03,
JP100,PinHeader_1x03_P2.54mm_Vertical,1,Jumper_3_Open,
L100,L_Bourns_SRR1208_12.7x12.7mm,1,220u,
L200,1206,1,10u,
MMA8451,QFN50P300X300X100-16N,1,MMA8451QR1,
MPU6050,InvenSense_QFN-24_4x4mm_P0.5mm,1,MPU-6050,
Q100,bsp171,1,BSP 171,
R100,0603,1,10k,
R102,0603,1,1k,
R103,0603,1,127k,
R104,0603,1,14k,
R105,0603,1,47k,
R106,0603,1,4M7,
R107,0603,1,1k,
R108,0603,1,499k,
R109,0603,1,10k,
R200,0603,1,10k,
R201,0603,1,0,
R202,0603,1,2k2,
R203,0603,1,2k2,
R204,0603,1,1k,
R205,0603,1,1k,
R206,0603,1,1k,
R207,0603,1,1k,
R208,0603,1,5k1,
R209,0603,1,5k1,
R300,0603,1,10k,
R301,0603,1,100,
R302,0603,1,100,
R303,0603,1,22,
R405,0603,1,22,
R406,0603,1,22,
R407,0603,1,22,
RV1,TRIM_TC33X-2-103E,1,R_Potentiometer_Small,
SW200,SW_SPDT_PCM12,1,BOOT0,
U1,SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.95x4.9mm_Mask2.71x3.4mm_ThermalVias,1,LM5017MR,
U101,SOT-223-3_TabPin2,1,LVR 3.3V,
U200,LQFP-64_10x10mm_P0.5mm,1,STM32F405RGT6,
U201,SOT-23-6,1,USBLC6-2SC6,
USB_C1,JAE_DX07S016JA1R1500,1,USB_C_receptacle,
Y200,Crystal_SMD_3225-4Pin_3.2x2.5mm,1,16Mhz,

## Commit log

2023-03-10 Added files
2023-03-11 lade till allt annat
